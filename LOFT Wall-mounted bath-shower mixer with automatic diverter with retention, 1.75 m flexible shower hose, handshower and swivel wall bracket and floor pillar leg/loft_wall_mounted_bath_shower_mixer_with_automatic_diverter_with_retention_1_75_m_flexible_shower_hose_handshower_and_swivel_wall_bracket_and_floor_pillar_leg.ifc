Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: loft_wall_mounted_bath_shower_mixer_with_automatic_diverter_with_retention_1_75_m_flexible_shower_hose_handshower_and_swivel_wall_bracket_and_floor_pillar_leg.ifc
Time: 2017-05-16T12:51:49
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2015
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: LOFT Wall-mounted bath-shower mixer with automatic diverter with retention, 1.75 m flexible shower hose, handshower and swivel wall bracket and floor pillar leg
ePset_BIMobject_Lena - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): LOFT Wall-mounted bath-shower mixer with automatic diverter with retention, 1.75 m flexible shower hose, handshower and swivel wall bracket and floor pillar leg; SKU (BO_prodsku): 5A2743C00; ManufacturName (BO_Manufac): Roca; BrandUrl (BO_brandurl): http://www.roca.es; ProductFamily (BO_prodfam): Loft; ProductGroup (BO_prodgroup): Faucets; DesignCountry (BO_designcont): Spain; PublishDate (BO_publisdat): 10/11/2016; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/roca/product/5A2743C00; ProductDataUrl (BO_prodaturl): bimobject.com/roca/product/5A2743C00; ProductUrl (BO_producturl): http://www.roca.com/catalogue/products/faucets/bath-faucets/twin-lever/wall-mounted-bath-shower-mixer-automatic-diverter-retention-1-75m-flexible-shower-hose-handshower-swivel-wall-bracket-floor-pillar-leg-5A2743C00; InstallationInstructions (BO_montins): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={9B46C372-A38C-4038-9F58-83617DB00210}; TechnicalDescription (BO_techcert): http://www.roca.com/RocaResourceServlet/resources/getMainResource?idObject={C7E15908-FF81-4C91-A245-BBBE97C32E18}; InstructionVideo (BO_youtube): https://www.youtube.com/watch?v=68jtjk-3_i4; MaterialMain (BO_mainmat): Chrome; BimObjectCategory (BO_bocat): Taps & Mixers; IfcClassification (BO_ifcclas): Sanitary Terminal; Uniclass14Code (BO_uniclass_1_4_code): L725111; Uniclass14Description (BO_uniclass_1_4_desc): Mixer taps; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
